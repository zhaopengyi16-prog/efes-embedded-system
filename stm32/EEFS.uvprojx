# Keil uVision project EEFS.uvprojx, settings and files
target App (6240000::V6.24::ARMCLANG)
  device: STM32G431RBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.6.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(16000000) ELITTLE
  output: EEFS +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32G431xx
  c include: .\Control16-10-2026\CMSIS\Core\Include;.\Control16-10-2026\CMSIS\Dvice\Include;.\Control16-10-2026\APP;.\Control16-10-2026\BSP
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group App
    ./Control16-10-2026/APP/: main.c
  group BSP
    ./Control16-10-2026/BSP/: gpio.c gpio.h uart.c uart.h systick.c systick.h key.c key.h
  group CMSIS
    ./Control16-10-2026/CMSIS/Dvice/Source/: system_stm32g4xx.c startup_stm32g431xx.s
